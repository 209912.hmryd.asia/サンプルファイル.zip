03-03-z (Autodesk Fusion 360 design; units mm, degrees)
sphere_primitive "球プリミティブ" Diameter 50