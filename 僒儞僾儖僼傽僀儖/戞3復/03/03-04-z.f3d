03-04-z (Autodesk Fusion 360 design; units mm, degrees)
step "トーラス プリミティブ" MinorDiameter 20 MajorDiameter 80